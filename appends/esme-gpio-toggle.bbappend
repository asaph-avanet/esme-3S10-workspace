inherit externalsrc
EXTERNALSRC = "/home/asaph/w/src/esme-3S10/esme-3S10-gpio-toggle"
EXTERNALSRC_BUILD = "/home/asaph/w/src/esme-3S10/esme-3S10-gpio-toggle"
