IMAGE_INSTALL:append = " esme-gpio-toggle"
